FASTBOOTPKG_INSTALL = "flashing-script u-boot-beaglev-ahead linux-beaglev-dev"
